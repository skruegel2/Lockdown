# IAR project LD_SBM.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F429ZI ST STM32F429ZI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: SBM_VERSION_CHECKING=0; SBM_BOOT_STATUS_TRACKING=0; SBM_UPDATE_LOGGING=0; SBM_FAIL_LAUNCH_API=0; SBM_BOOT_INTEGRITY_CHECKING=5; SBM_RECORD_BOOT_TIME=0; SBM_REPORT_SBM_SIZES=0; SBM_EXTENDED_SWUP_ERRORS=0; SBM_LOG_VERBOSITY=0; SBM_ENABLE_LOG_BOOT_STATUS=0; SBM_ENABLE_LOG_BOOT_TIME=0; SBM_ENABLE_LOG_SIZES=0; SBM_ENABLE_LOG_UPDATE_STATUS=0; SBM_ENABLE_LOG_DATASTORE=0; SBM_ENABLE_LOG_OEM=0; SBM_SUPPORT_ENCRYPTED_UPDATES=1; SBM_ADDRESS=134217728; SBM_END_ADDRESS=134283263; SBM_EXECUTABLE_ADDRESS=134348800; SBM_EXECUTABLE_END_ADDRESS=135266303; SBM_MUH_ADDRESS=134283264; SBM_MUH_END_ADDRESS=134348799; SBM_SECAPI_ACCESS_WINDOW_START=134218204; SBM_SECAPI_ACCESS_WINDOW_END=134218207; SBM_PPD_ENABLE=0; SBM_PPD_4BYTE_SECURITY_CONTEXT_SEED="\xc5\x9c\xc8\x80"; SBM_PROVISIONED_DATA_ENCRYPTED=0; SBM_TZ_FIREWALL_ACTIVE=0; SBM_FORWARD_HARDFAULTS=0; SBM_EXT_UPDATE_FLASH_ENABLE=0; SBM_APPLICATION_INTERFACE_METHOD_STZ_INDIRECTION=1; SBM_APPLICATION_INTERFACE_METHOD_ARM_TRUSTZONE=0; SBM_LD_IMMEDIATE_DEBUG_PERM=0; SBM_LD_IMMEDIATE_DEBUG_TEMP=0; SBM_LD_DELAYED_DEBUG_PERM=0; SBM_LD_DELAYED_DEBUG_TEMP=0; USE_HAL_DRIVER=1; STM32F429xx=1; USE_IOEXPANDER=1; SBM_REPORT_SBM_VERSION=1; SBM_REPORT_SBM_BUILD_TIME=1; SBM_INCLUDE_CONSOLE=1
  ICCARM.CCIncludePath2: SBM\hal; SBM\OEM\target\ST\stm32f429xi; SBM\..\third_party\FOSS\tomcrypt\src; SBM\hal\soc; SBM\..\third_party\FOSS\kmackay\stz; SBM\Inc; SBM\..\third_party\FOSS\IETF\sha; SBM\..\third_party\arm\CMSIS\Core\Include; SBM\..\third_party\st\STM32Cube_F4\STM_HAL_Driver\Inc; SBM\Inc\sbm; SBM\..\third_party\FOSS\tomcrypt\include; SBM\..\third_party\st\STM32Cube_F4\CMSIS; SBM\Src\Swup; SBM\..\common\hal\inc; SBM\Src\Crypto; SBM\hal\cpu\arm; SBM\..\third_party\FOSS\kmackay\micro-ecc; SBM\hal\soc\ST\STM32F429XI; SBM\..\third_party\st\STM32Cube_F4\STM_HAL_Driver\Inc\Legacy; SBM\..\common\SecureApi\Inc; SBM\..; $TOOLKIT_DIR$\CMSIS\Core\Include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  ILINK.IlinkOutputFile: LD_SBM.out
  ILINK.IlinkIcfFile: stm32f429xi.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; SBM_VERSION_CHECKING=0; SBM_BOOT_STATUS_TRACKING=0; SBM_UPDATE_LOGGING=0; SBM_FAIL_LAUNCH_API=0; SBM_BOOT_INTEGRITY_CHECKING=5; SBM_RECORD_BOOT_TIME=0; SBM_REPORT_SBM_SIZES=0; SBM_EXTENDED_SWUP_ERRORS=0; SBM_LOG_VERBOSITY=0; SBM_ENABLE_LOG_BOOT_STATUS=0; SBM_ENABLE_LOG_BOOT_TIME=0; SBM_ENABLE_LOG_SIZES=0; SBM_ENABLE_LOG_UPDATE_STATUS=0; SBM_ENABLE_LOG_DATASTORE=0; SBM_ENABLE_LOG_OEM=0; SBM_SUPPORT_ENCRYPTED_UPDATES=1; SBM_ADDRESS=134217728; SBM_END_ADDRESS=134283263; SBM_EXECUTABLE_ADDRESS=134348800; SBM_EXECUTABLE_END_ADDRESS=135266303; SBM_MUH_ADDRESS=134283264; SBM_MUH_END_ADDRESS=134348799; SBM_SECAPI_ACCESS_WINDOW_START=134218204; SBM_SECAPI_ACCESS_WINDOW_END=134218207; SBM_PPD_ENABLE=0; SBM_PPD_4BYTE_SECURITY_CONTEXT_SEED="\xc5\x9c\xc8\x80"; SBM_PROVISIONED_DATA_ENCRYPTED=0; SBM_TZ_FIREWALL_ACTIVE=0; SBM_FORWARD_HARDFAULTS=0; SBM_EXT_UPDATE_FLASH_ENABLE=0; SBM_APPLICATION_INTERFACE_METHOD_STZ_INDIRECTION=1; SBM_APPLICATION_INTERFACE_METHOD_ARM_TRUSTZONE=0; SBM_LD_IMMEDIATE_DEBUG_PERM=0; SBM_LD_IMMEDIATE_DEBUG_TEMP=0; SBM_LD_DELAYED_DEBUG_PERM=0; SBM_LD_DELAYED_DEBUG_TEMP=0; USE_HAL_DRIVER=1; STM32F429xx=1; USE_IOEXPANDER=1; SBM_REPORT_SBM_VERSION=1; SBM_REPORT_SBM_BUILD_TIME=1; SBM_INCLUDE_CONSOLE=1
  ICCARM.CCOptLevel: 3
  group (top)
    ./: sbm.ipcf
  group SBM/../common/hal/inc
    common/hal/inc/: hal_rng.h
  group SBM/../common/SecureApi/Inc
    common/SecureApi/Inc/: imageInfo.h secureApiData.h secureApiExport.h secureApiFunctionList.i secureApiInternal.h secureApiReturnCodes.h
  group SBM/../third_party/arm/CMSIS/Core/Include
    third_party/arm/CMSIS/Core/Include/: cachel1_armv7.h cmsis_armcc.h cmsis_armclang.h cmsis_armclang_ltm.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_version.h core_armv81mml.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm35p.h core_cm4.h core_cm55.h core_cm7.h core_sc000.h core_sc300.h mpu_armv7.h mpu_armv8.h pmu_armv8.h tz_context.h
  group SBM/../third_party/FOSS/IETF/sha
    third_party/FOSS/IETF/sha/: sha-private.h sha.h sha224-256.c usha.c usha.h
  group SBM/../third_party/FOSS/kmackay/micro-ecc
    third_party/FOSS/kmackay/micro-ecc/: curve-specific.h platform-specific.h types.h uECC.h uECC_c.h uECC_vli.h
  group SBM/../third_party/FOSS/kmackay/stz
    third_party/FOSS/kmackay/stz/: ecc.c ecc.h
  group SBM/../third_party/FOSS/tomcrypt/include
    third_party/FOSS/tomcrypt/include/: tomcrypt.h tomcrypt_argchk.h tomcrypt_cfg.h tomcrypt_cipher.h tomcrypt_custom.h tomcrypt_hash.h tomcrypt_mac.h tomcrypt_macros.h tomcrypt_math.h tomcrypt_misc.h tomcrypt_pk.h tomcrypt_pkcs.h tomcrypt_prng.h
  group SBM/../third_party/FOSS/tomcrypt/src
    third_party/FOSS/tomcrypt/src/: aes.c aes_tab.h burn_stack.c crypt.c crypt_argchk.c crypt_cipher_descriptor.c crypt_cipher_is_valid.c crypt_find_cipher.c crypt_find_cipher_any.c crypt_find_cipher_id.c crypt_register_cipher.c crypt_unregister_cipher.c gcm_add_aad.c gcm_add_iv.c gcm_done.c gcm_gf_mult.c gcm_init.c gcm_memory.c gcm_mult_h.c gcm_process.c gcm_reset.c zeromem.c
  group SBM/../third_party/st/STM32Cube_F4/CMSIS
    third_party/st/STM32Cube_F4/CMSIS/: stm32f407xx.h stm32f412zx.h stm32f429xx.h stm32f469xx.h stm32f4xx.h system_stm32f4xx.h
  group SBM/../third_party/st/STM32Cube_F4/STM_HAL_Driver/Inc
    third_party/st/STM32Cube_F4/STM_HAL_Driver/Inc/: stm32f4xx_hal.h stm32f4xx_hal_cortex.h stm32f4xx_hal_def.h stm32f4xx_hal_dma.h stm32f4xx_hal_dma_ex.h stm32f4xx_hal_flash.h stm32f4xx_hal_flash_ex.h stm32f4xx_hal_flash_ramfunc.h stm32f4xx_hal_gpio.h stm32f4xx_hal_gpio_ex.h stm32f4xx_hal_i2c.h stm32f4xx_hal_i2c_ex.h stm32f4xx_hal_pwr.h stm32f4xx_hal_pwr_ex.h stm32f4xx_hal_rcc.h stm32f4xx_hal_rcc_ex.h stm32f4xx_hal_rng.h stm32f4xx_hal_spi.h stm32f4xx_hal_uart.h stm32f4xx_hal_usart.h stm32f4xx_ll_utils.h
  group SBM/../third_party/st/STM32Cube_F4/STM_HAL_Driver/Inc/Legacy
    third_party/st/STM32Cube_F4/STM_HAL_Driver/Inc/Legacy/: stm32_hal_legacy.h
  group SBM/../third_party/st/STM32Cube_F4/STM_HAL_Driver/Src
    third_party/st/STM32Cube_F4/STM_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_tim.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_ll_usart.c
  group SBM/[Linker]
    ./: autogenerated_sbm_symbols.icf stm32f429xi.icf
  group SBM/autogenerated
    ./: autogenerated_memory_devices_and_slots.h
  group SBM/hal
    SBM/hal/: memory_devices_and_slots.c memory_devices_and_slots.h sbm_hal.c sbm_hal.h sbm_hal_crypto.c sbm_hal_crypto.h sbm_hal_mem.c sbm_hal_mem.h sbm_hal_serial.c sbm_hal_serial.h sbm_hal_tick.c sbm_hal_timer.c
  group SBM/hal/cpu/arm
    SBM/hal/cpu/arm/: cpu_exception.c cpu_interrupt.c cpu_interrupt.h cpu_sau.c cpu_sau.h cpu_std_vectors.s cpu_support.c cpu_support_sbm.c sbm_hal_cpu.h
  group SBM/hal/soc
    SBM/hal/soc/: soc_flash.h soc_flash_generic.c soc_hal_crypto.h soc_lockdown.h soc_lockdown_generic.c
  group SBM/hal/soc/ST/STM32F429XI
    SBM/hal/soc/ST/STM32F429XI/: hal_gpio.c hal_gpio.h hal_led.c hal_led.h hal_rng.c memory_map_flash.h memoryMap.h sbm_hal_soc.h soc_arm_cmsis.h soc_flash.c soc_get_device_trust_anchor.c soc_lockdown.c soc_read_device_id.c soc_read_device_id.h soc_rng.h soc_stm32f4xx.c soc_stm32f4xx_flash.h soc_stm32xx.c soc_stm32xx.h soc_stm32xx_rng.c soc_stm32xx_rng.h soc_stm32xx_sbm.c soc_target_string.c soc_timer.c startup_stm32f429xx.s stm32f4xx_clock.c stm32f4xx_flash_map.c stm32f4xx_flash_map.h stm32f4xx_hal_conf.h system_stm32f4xx.c
  group SBM/Inc
    SBM/Inc/: benchmark.h bufferCheck.h crypto.h dataStore.h dataStore_types.h lockdown.h oem.h oem_ext_mm.h oem_flash_ext.h sbm_api.h sbm_log.h sbm_log_boot_status.h sbm_log_boot_time.h sbm_log_datastore.h sbm_log_oem.h sbm_log_sizes.h sbm_log_update_status.h static.h swup.h
  group SBM/Inc/sbm
    SBM/Inc/sbm/: sbm_memory.h
  group SBM/OEM
    SBM/OEM/: oem.c
  group SBM/OEM/target/ST/stm32f429xi
    SBM/OEM/target/ST/stm32f429xi/: hal_console.c hal_console.h oem_board.c oem_board.h oem_boot_signal.c oem_bsp.h oem_iar_stm32f429ii_aca.h oem_led.c oem_serial.c oem_st_stm32f429i_disc1.h
  group SBM/Src
    SBM/Src/: main.c sbm_api.c
  group SBM/Src/Crypto
    SBM/Src/Crypto/: aesgcm_types.h ecies_crypto.c ecies_crypto.h sha256_wrapper.c sha256_wrapper.h tomcrypt_api.c tomcrypt_api.h
  group SBM/Src/Secure_api
    SBM/Src/Secure_api/: secureApi.c
  group SBM/Src/Support
    SBM/Src/Support/: benchmark.c bufferCheck.c dataStore.c imageInfo.c lockdown.c sbm_log.c
  group SBM/Src/Swup
    SBM/Src/Swup/: swup.c swup_capability_defines.h swup_checksum_and_hash.c swup_checksum_and_hash.h swup_eub.h swup_header_magic.h swup_layout.h swup_metadata.h swup_muh.c swup_muh.h swup_oem.c swup_oem.h swup_optional_element.c swup_optional_element.h swup_priority_queue.c swup_priority_queue.h swup_public_key.c swup_public_key.h swup_read.c swup_read.h swup_sbm_update_slot_contains_swup.c swup_sbm_update_slot_contains_swup.h swup_signature.h swup_status_error_code.h swup_supported_defines.h swup_tlv.c swup_tlv.h swup_uuid.c swup_uuid.h
