<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\LD_SBM.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\Lockdown.ewp</path>
    </project>
    <batchBuild />
</workspace>
